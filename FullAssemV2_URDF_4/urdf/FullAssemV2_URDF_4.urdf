Commit message: Cleanup

File: FullAssemV2_URDF_4/urdf/FullAssemV2_URDF_4.urdf (robot description, URDF)
Before this commit: robot FullAssemV2_URDF_4, 13 links, 12 joints
Links:
- link Thigh4_Link: mass 0 -> 0.0539963764620715
